# Keil uVision project Project.uvprojx, settings and files
target STM32072B_EVAL (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F072RBTx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: STM32072B_EVAL
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F072xB,USE_HAL_DRIVER,USE_STM32072B_EVAL,
  c misc: --C99
  c include: ..\Inc;..\..\..\Drivers\CMSIS\Device\ST\STM32F0xx\Include;..\..\..\Drivers\STM32F0xx_HAL_Driver\Inc;..\..\..\Drivers\BSP\Components\Common;..\..\..\Utilities\Log;..\..\..\Utilities\CPU;..\..\..\Drivers\BSP\STM32072B_EVAL;..\..\..\Drivers\STM32F0xx_HAL_Driver\Inc\Legacy;..\..\Common_IR\inc;..\..\..\Drivers\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --diag_suppress=L6329
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../Drivers/BSP/Components/hx8347d/: hx8347d.c
    ../../../Drivers/BSP/Components/spfd5408/: spfd5408.c
  group Drivers/BSP/STM32072B_EVAL
    ../../../Drivers/BSP/STM32072B_EVAL/: stm32072b_eval.c stm32072b_eval_lcd.c
  group Drivers/CMSIS
    ../../../Drivers/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
  group Drivers/STM32F0xx_HAL_Driver
    ../../../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal.c stm32f0xx_hal_cortex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_rcc.c stm32f0xx_hal_spi.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_dma.c
  group Example/MDK-ARM
    ./: startup_stm32f072xb.s
  group Example/User
    ../Src/: main.c menu.c stm32f0xx_hal_msp.c stm32f0xx_it.c
    ../../Common_IR/src/: ir_common.c rc5_decode.c rc5_encode.c sirc_decode.c sirc_encode.c
