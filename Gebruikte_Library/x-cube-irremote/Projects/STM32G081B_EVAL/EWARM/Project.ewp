# IAR project Project.ewp, settings and files
configuration STM32G081B_EVAL (ARM, debug)
  General.OGChipSelectEditMenu: STM32G081RB ST STM32G081RB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: STM32G081xx; USE_HAL_DRIVER; USE_STM32G081B_EVAL; LCD_DEFAULT_FONT=Font24
  ICCARM.CCIncludePath2: ../Inc; ../../../Drivers/STM32G0xx_HAL_Driver/Inc; ../../../Drivers/CMSIS/Device/ST/STM32G0xx/Include; ../../../Drivers/BSP/STM32G081B_EVAL; ../../../Drivers/BSP/Components/Common; ../../../Drivers/CMSIS/Include; ..\..\Common_IR\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: binary.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32g081xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32g081xx.s
  group Application/User
    ../Src/: main.c menu.c stm32g0xx_hal_msp.c stm32g0xx_it.c
  group Application/User/IR
    ../../Common_IR/src/: ir_common.c rc5_decode.c rc5_encode.c sirc_decode.c sirc_encode.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../Drivers/BSP/Components/hx8347d/: hx8347d.c
  group Drivers/BSP/STM32G081B_EVAL
    ../../../Drivers/BSP/STM32G081B_EVAL/: stm32g081b_eval.c stm32g081b_eval_lcd.c
  group Drivers/CMSIS
    ../Src/: system_stm32g0xx.c
  group Drivers/STM32G0xx_HAL_Driver
    ../../../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal.c stm32g0xx_hal_cortex.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_hal_exti.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_hal_spi.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c
