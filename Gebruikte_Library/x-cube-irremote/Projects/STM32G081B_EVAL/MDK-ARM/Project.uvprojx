# Keil uVision project Project.uvprojx, settings and files
target ProjectG0 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32G081RBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00008000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: Templates +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32G081xx,USE_STM32G081B_EVAL
  c include: ../Inc;../../../Drivers/STM32G0xx_HAL_Driver/Inc;../../../Drivers/CMSIS/Device/ST/STM32G0xx/Include;../../../Drivers/BSP/STM32G081B_EVAL;..\..\Common_IR\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32g081xx.s
  group Application/User
    ../Src/: main.c stm32g0xx_it.c stm32g0xx_hal_msp.c menu.c
    ../../Common_IR/src/: ir_common.c rc5_decode.c rc5_encode.c sirc_decode.c sirc_encode.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32G081B_EVAL
    ../../../Drivers/BSP/STM32G081B_EVAL/: stm32g081b_eval.c stm32g081b_eval_lcd.c
  group Drivers/STM32G0xx_HAL_Driver
    ../../../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_cortex.c stm32g0xx_hal.c stm32g0xx_hal_gpio.c stm32g0xx_hal_spi.c stm32g0xx_hal_spi_ex.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32g0xx.c
  group Drivers/BSP/Components
    ../../../Drivers/BSP/Components/hx8347d/: hx8347d.c
software components: CMSIS:CORE 4.3.0
