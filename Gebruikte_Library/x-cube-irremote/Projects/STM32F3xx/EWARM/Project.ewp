# IAR project Project.ewp, settings and files
configuration STM32373C_EVAL (ARM, debug)
  General.OGChipSelectEditMenu: STM32F373VC ST STM32F373VC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F373xC; USE_HAL_DRIVER; USE_STM32373C_EVAL
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\Drivers\CMSIS\Device\ST\STM32F3xx\Include; ..\..\..\Drivers\STM32F3xx_HAL_Driver\Inc; ..\..\..\Drivers\BSP\STM32373C_EVAL; ..\..\..\Drivers\BSP\Components\Common; ..\..\..\Utilities\Log; ..\..\..\Utilities\CPU; ..\..\Common_IR\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32373C_EVAL.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f373xc_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM32303C_EVAL (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: STM32F303xC; USE_HAL_DRIVER; USE_STM32303C_EVAL
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\Drivers\CMSIS\Device\ST\STM32F3xx\Include; ..\..\..\Drivers\STM32F3xx_HAL_Driver\Inc; ..\..\..\Drivers\BSP\Components\Common; ..\..\..\Utilities\Log; ..\..\..\Utilities\CPU; ..\..\..\Drivers\BSP\STM32303C_EVAL; ..\..\Common_IR\inc
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../Drivers/BSP/Components/cs43l22/: cs43l22.c
    ../../../Drivers/BSP/Components/hx8347d/: hx8347d.c
    ../../../Drivers/BSP/Components/hx8347g/: hx8347g.c
    ../../../Drivers/BSP/Components/ili9328/: ili9328.c
    ../../../Drivers/BSP/Components/spfd5408/: spfd5408.c
  group Drivers/BSP/STM32303C_EVAL
    ../../../Drivers/BSP/STM32303C_EVAL/: stm32303c_eval.c stm32303c_eval_lcd.c
  group Drivers/BSP/STM32373C_EVAL
    ../../../Drivers/BSP/STM32373C_EVAL/: stm32373c_eval.c stm32373c_eval_lcd.c
  group Drivers/CMSIS
    ../Src/: system_stm32f3xx.c
  group Drivers/STM32F3xx_HAL_Driver
    ../../../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal.c stm32f3xx_hal_cortex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_rcc.c stm32f3xx_hal_spi.c stm32f3xx_hal_tim.c stm32f3xx_hal_tim_ex.c
  group Example/EWARM
    ./: startup_stm32f303xc.s startup_stm32f373xc.s
  group Example/User
    ../../Common_IR/src/: ir_common.c rc5_decode.c rc5_encode.c sirc_decode.c sirc_encode.c
    ../Src/: main.c menu.c stm32f3xx_hal_msp.c stm32f3xx_it.c
