# Keil uVision project Project.uvprojx, settings and files
target STM32373C_EVAL (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F373VCHx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00008000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32373C_EVAL
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F373xC,USE_HAL_DRIVER,USE_STM32373C_EVAL,
  c misc: --C99
  c include: ..\Inc;..\..\..\Drivers\CMSIS\Device\ST\STM32F3xx\Include;..\..\..\Drivers\STM32F3xx_HAL_Driver\Inc;..\..\..\Drivers\BSP\STM32373C_EVAL;..\..\..\Drivers\BSP\Components\Common;..\..\..\Utilities\Log;..\..\..\Utilities\CPU;..\..\Common_IR\inc;..\..\..\Drivers\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --diag_suppress=L6329
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../Drivers/BSP/Components/hx8347d/: hx8347d.c
    ../../../Drivers/BSP/Components/spfd5408/: spfd5408.c
    ../../../Drivers/BSP/Components/hx8347g/: hx8347g.c
    ../../../Drivers/BSP/Components/ili9328/: ili9328.c
  group Drivers/BSP/STM32303C_EVAL
    ../../../Drivers/BSP/STM32303C_EVAL/: stm32303c_eval.c stm32303c_eval_lcd.c
  group Drivers/BSP/STM32373C_EVAL
    ../../../Drivers/BSP/STM32373C_EVAL/: stm32373c_eval.c stm32373c_eval_lcd.c
  group Drivers/CMSIS
    ../Src/: system_stm32f3xx.c
  group Drivers/STM32F3xx_HAL_Driver
    ../../../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal.c stm32f3xx_hal_cortex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_rcc.c stm32f3xx_hal_spi.c stm32f3xx_hal_tim.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_dma.c
  group Example/MDK-ARM
    ./: startup_stm32f303xc.s startup_stm32f373xc.s
  group Example/User
    ../Src/: main.c menu.c stm32f3xx_hal_msp.c stm32f3xx_it.c
    ../../Common_IR/src/: ir_common.c rc5_decode.c rc5_encode.c sirc_decode.c sirc_encode.c
target STM32303C_EVAL (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F303VCTx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x0000C000) IRAM2(0x10000000,0x00002000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32303C_EVAL
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F303xC,USE_HAL_DRIVER,USE_STM32303C_EVAL,
  c misc: --C99
  c include: ..\Inc;..\..\..\Drivers\CMSIS\Device\ST\STM32F3xx\Include;..\..\..\Drivers\STM32F3xx_HAL_Driver\Inc;..\..\..\Drivers\BSP\Components\Common;..\..\..\Utilities\Log;..\..\..\Utilities\CPU;..\..\..\Drivers\BSP\STM32303C_EVAL;..\..\..\Drivers\CMSIS\Include;..\..\Common_IR\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x2000
  link misc: --diag_suppress=L6329
